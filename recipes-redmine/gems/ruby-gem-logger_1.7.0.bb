inherit ruby-gem
GEM_NAME = "logger"
SRC_URI[sha256sum] = "196edec7cc44b66cfb40f9755ce11b392f21f7967696af15d274dde7edff0203"
