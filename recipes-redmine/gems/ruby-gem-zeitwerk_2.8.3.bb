inherit ruby-gem
GEM_NAME = "zeitwerk"
SRC_URI[sha256sum] = "2c85125a8467ce069e20123d1e709a08955c9d29c118c25b46b7b7fafdbb92e5"
