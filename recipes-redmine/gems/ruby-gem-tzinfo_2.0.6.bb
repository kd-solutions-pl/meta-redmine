inherit ruby-gem
GEM_NAME = "tzinfo"
SRC_URI[sha256sum] = "8daf828cc77bcf7d63b0e3bdb6caa47e2272dcfaf4fbfe46f8c3a9df087a829b"
RDEPENDS:${PN} += "ruby-gem-concurrent-ruby"

