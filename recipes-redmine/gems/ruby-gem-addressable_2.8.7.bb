inherit ruby-gem
GEM_NAME = "addressable"
SRC_URI[sha256sum] = "462986537cf3735ab5f3c0f557f14155d778f4b43ea4f485a9deb9c8f7c58232"
RDEPENDS:${PN} += "ruby-gem-public-suffix"

