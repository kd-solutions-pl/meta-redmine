inherit ruby-gem
GEM_NAME = "net-protocol"
SRC_URI[sha256sum] = "ba310c3d4f1cad46bb1ab20336b06669b1ff8f7c568d9cb9342b32a718547472"
RDEPENDS:${PN} += "ruby-gem-timeout"
