inherit ruby-gem
GEM_NAME = "base64"
SRC_URI[sha256sum] = "27337aeabad6ffae05c265c450490628ef3ebd4b67be58257393227588f5a97b"
