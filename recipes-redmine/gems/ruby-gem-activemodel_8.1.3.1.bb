inherit ruby-gem
GEM_NAME = "activemodel"
SRC_URI[sha256sum] = "99cc02ce2faec371d14440949d85787ebd23a907c9baef0a9d4bcd4d21888f88"
RDEPENDS:${PN} += "ruby-gem-activesupport"
