inherit ruby-gem
GEM_NAME = "concurrent-ruby"
SRC_URI[sha256sum] = "b2f1be836e968ccc78ccfce277ea79c72a88633f22306782c16ff23fb415d1e1"
