inherit ruby-gem
GEM_NAME = "timeout"
SRC_URI[sha256sum] = "9509f079b2b55fe4236d79633bd75e34c1c1e7e3fb4b56cb5fda61f80a0fe30e"

