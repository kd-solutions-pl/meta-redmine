inherit ruby-gem
GEM_NAME = "mini_mime"
SRC_URI[sha256sum] = "8681b7e2e4215f2a159f9400b5816d85e9d8c6c6b491e96a12797e798f8bccef"
