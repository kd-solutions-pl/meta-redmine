inherit ruby-gem
GEM_NAME = "zeitwerk"
SRC_URI[sha256sum] = "0945986050e4907140895378e74df1fe882a2271ed087cc6c6d6b00d415a2756"

