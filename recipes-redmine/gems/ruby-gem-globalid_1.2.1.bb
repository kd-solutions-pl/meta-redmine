inherit ruby-gem
GEM_NAME = "globalid"
SRC_URI[sha256sum] = "70bf76711871f843dbba72beb8613229a49429d1866828476f9c9d6ccc327ce9"
RDEPENDS:${PN} += "ruby-gem-activesupport"

