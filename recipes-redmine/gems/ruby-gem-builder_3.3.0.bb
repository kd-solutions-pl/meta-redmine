inherit ruby-gem
GEM_NAME = "builder"
SRC_URI[sha256sum] = "497918d2f9dca528fdca4b88d84e4ef4387256d984b8154e9d5d3fe5a9c8835f"

