inherit ruby-gem
GEM_NAME = "rb-fsevent"
SRC_URI[sha256sum] = "43900b972e7301d6570f64b850a5aa67833ee7d87b458ee92805d56b7318aefe"

