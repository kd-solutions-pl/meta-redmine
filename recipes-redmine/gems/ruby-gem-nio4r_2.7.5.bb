inherit ruby-gem
GEM_NAME = "nio4r"
SRC_URI[sha256sum] = "6c90168e48fb5f8e768419c93abb94ba2b892a1d0602cb06eef16d8b7df1dca1"
