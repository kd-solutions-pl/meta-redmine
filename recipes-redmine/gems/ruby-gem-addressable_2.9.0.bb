inherit ruby-gem
GEM_NAME = "addressable"
SRC_URI[sha256sum] = "7fdf6ac3660f7f4e867a0838be3f6cf722ace541dd97767fa42bc6cfa980c7af"
RDEPENDS:${PN} += "ruby-gem-public-suffix"
