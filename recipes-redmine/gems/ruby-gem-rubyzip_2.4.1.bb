inherit ruby-gem
GEM_NAME = "rubyzip"
SRC_URI[sha256sum] = "8577c88edc1fde8935eb91064c5cb1aef9ad5494b940cf19c775ee833e075615"

