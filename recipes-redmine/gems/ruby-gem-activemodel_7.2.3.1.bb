inherit ruby-gem
GEM_NAME = "activemodel"
SRC_URI[sha256sum] = "39e1869b85e7a0b64a8ccddf19f3fb0c44261b329785384bb88f878eab51c0d0"
RDEPENDS:${PN} += "ruby-gem-activesupport"

