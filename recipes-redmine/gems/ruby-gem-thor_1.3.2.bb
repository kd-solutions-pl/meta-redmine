inherit ruby-gem
GEM_NAME = "thor"
SRC_URI[sha256sum] = "eef0293b9e24158ccad7ab383ae83534b7ad4ed99c09f96f1a6b036550abbeda"

