inherit ruby-gem
GEM_NAME = "net-smtp"
SRC_URI[sha256sum] = "5fc0415e6ea1cc0b3dfea7270438ec22b278ca8d524986a3ae4e5ae8d087b42a"
RDEPENDS:${PN} += "ruby-gem-net-protocol"

