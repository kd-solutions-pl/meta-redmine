inherit ruby-gem
GEM_NAME = "public_suffix"
SRC_URI[sha256sum] = "1a8bb08f1bbea19228d3bed6e5ed908d1cb4f7c2726d18bd9cadf60bc676f623"
