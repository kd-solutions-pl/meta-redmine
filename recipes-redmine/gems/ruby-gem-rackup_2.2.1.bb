inherit ruby-gem
GEM_NAME = "rackup"
SRC_URI[sha256sum] = "f737191fd5c5b348b7f0a4412a3b86383f88c43e13b8217b63d4c8d90b9e798d"
RDEPENDS:${PN} += "ruby-gem-rack"

