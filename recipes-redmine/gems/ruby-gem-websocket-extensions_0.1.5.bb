inherit ruby-gem
GEM_NAME = "websocket-extensions"
SRC_URI[sha256sum] = "1c6ba63092cda343eb53fc657110c71c754c56484aad42578495227d717a8241"

