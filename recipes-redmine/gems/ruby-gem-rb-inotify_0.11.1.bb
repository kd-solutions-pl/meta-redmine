inherit ruby-gem
GEM_NAME = "rb-inotify"
SRC_URI[sha256sum] = "a0a700441239b0ff18eb65e3866236cd78613d6b9f78fea1f9ac47a85e47be6e"
RDEPENDS:${PN} += "ruby-gem-ffi"

