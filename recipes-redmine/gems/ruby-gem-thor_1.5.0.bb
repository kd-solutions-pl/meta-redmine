inherit ruby-gem
GEM_NAME = "thor"
SRC_URI[sha256sum] = "e3a9e55fe857e44859ce104a84675ab6e8cd59c650a49106a05f55f136425e73"
