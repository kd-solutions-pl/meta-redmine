inherit ruby-gem
GEM_NAME = "rake"
SRC_URI[sha256sum] = "46cb38dae65d7d74b6020a4ac9d48afed8eb8149c040eccf0523bec91907059d"

