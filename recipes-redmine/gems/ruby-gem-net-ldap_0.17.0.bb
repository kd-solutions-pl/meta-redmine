inherit ruby-gem
GEM_NAME = "net-ldap"
SRC_URI[sha256sum] = "d62474b28b9f18d9108a7c859171bb1b9ebf0e1bc1d218e79170c0f373f729c8"

