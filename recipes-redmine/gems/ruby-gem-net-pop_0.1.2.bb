inherit ruby-gem
GEM_NAME = "net-pop"
SRC_URI[sha256sum] = "848b4e982013c15b2f0382792268763b748cce91c9e91e36b0f27ed26420dff3"
RDEPENDS:${PN} += "ruby-gem-net-protocol"

