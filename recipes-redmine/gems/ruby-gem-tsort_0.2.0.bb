inherit ruby-gem
GEM_NAME = "tsort"
SRC_URI[sha256sum] = "9650a793f6859a43b6641671278f79cfead60ac714148aabe4e3f0060480089f"
