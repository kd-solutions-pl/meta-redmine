inherit ruby-gem
GEM_NAME = "css_parser"
SRC_URI[sha256sum] = "f274988a40c6178305530d60e7deb5162f7b5538b701b61b5488fc703e5b40c1"
RDEPENDS:${PN} += "ruby-gem-addressable"

