inherit ruby-gem
GEM_NAME = "rdoc"
SRC_URI[sha256sum] = "db665021883ac9df3ba29cdf71aece960749888db1bf9615b4a584cfa3fa3eda"
RDEPENDS:${PN} += "ruby-gem-psych"

