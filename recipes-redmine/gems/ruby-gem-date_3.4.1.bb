inherit ruby-gem
GEM_NAME = "date"
SRC_URI[sha256sum] = "bf268e14ef7158009bfeaec40b5fa3c7271906e88b196d958a89d4b408abe64f"

