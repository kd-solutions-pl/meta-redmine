inherit ruby-gem
GEM_NAME = "rack-test"
SRC_URI[sha256sum] = "005a36692c306ac0b4a9350355ee080fd09ddef1148a5f8b2ac636c720f5c463"
RDEPENDS:${PN} += "ruby-gem-rack"

