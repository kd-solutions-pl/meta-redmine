inherit ruby-gem
GEM_NAME = "rack-session"
SRC_URI[sha256sum] = "0b6dc07dea7e4b583f58a48e8b806d4c9f1c6c9214ebc202ec94562cbea2e4e9"
RDEPENDS:${PN} += "ruby-gem-rack"

