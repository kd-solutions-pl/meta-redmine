inherit ruby-gem
GEM_NAME = "minitest"
SRC_URI[sha256sum] = "2d3b17f8a36fe7801c1adcffdbc38233b938eb0b4966e97a6739055a45fa77d5"

