inherit ruby-gem
GEM_NAME = "htmlentities"
SRC_URI[sha256sum] = "125a73c6c9f2d1b62100b7c3c401e3624441b663762afa7fe428476435a673da"

