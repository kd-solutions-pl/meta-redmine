inherit ruby-gem
GEM_NAME = "requestjs-rails"
SRC_URI[sha256sum] = "bb494198993b9bf136adeeffa3594c0143c7d16c7de4485c5e20d9c126e69a2d"
RDEPENDS:${PN} += "ruby-gem-railties"
