inherit ruby-gem
GEM_NAME = "rqrcode_core"
SRC_URI[sha256sum] = "cf4989dc82d24e2877984738c4ee569308625fed2a810960f1b02d68d0308d1a"

