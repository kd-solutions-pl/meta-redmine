inherit ruby-gem
GEM_NAME = "rake-compiler-dock"
SRC_URI[sha256sum] = "f13205c2738f3d2053afcd03491a9e4541b22a59a0bfc53fc8bc883bd8188023"
RDEPENDS:${PN} += "bash"
