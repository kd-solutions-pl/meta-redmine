inherit ruby-gem
GEM_NAME = "benchmark"
SRC_URI[sha256sum] = "0f12f8c495545e3710c3e4f0480f63f06b4c842cc94cec7f33a956f5180e874a"

