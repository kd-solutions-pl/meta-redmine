inherit ruby-gem
GEM_NAME = "action_text-trix"
SRC_URI[sha256sum] = "7012f59421009cf284aa651294896414d653a61a2417c9b8714c8476d2f74009"
RDEPENDS:${PN} += "ruby-gem-railties"
