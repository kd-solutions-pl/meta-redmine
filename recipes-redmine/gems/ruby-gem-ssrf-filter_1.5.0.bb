inherit ruby-gem
GEM_NAME = "ssrf_filter"
SRC_URI[sha256sum] = "e03dcdb9d1730d7f6710532a606b3543df2a448a0293ce04a2d995523c5a97f6"
