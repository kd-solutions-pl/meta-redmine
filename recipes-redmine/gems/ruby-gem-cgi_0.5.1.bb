inherit ruby-gem
GEM_NAME = "cgi"
SRC_URI[sha256sum] = "e93fcafc69b8a934fe1e6146121fa35430efa8b4a4047c4893764067036f18e9"

