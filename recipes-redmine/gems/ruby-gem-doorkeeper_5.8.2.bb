inherit ruby-gem
GEM_NAME = "doorkeeper"
SRC_URI[sha256sum] = "a73d07aeaf590b1e7e2a35390446f23131c9f37bc0561653e514d3973f4d50d3"
RDEPENDS:${PN} += "ruby-gem-railties"

