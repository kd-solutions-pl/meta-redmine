inherit ruby-gem
GEM_NAME = "doorkeeper-i18n"
SRC_URI[sha256sum] = "3dbc8558dd2883671a9de44f03fa9f71fbd2c3bf8f82cf6b4f55b6df5c4810a6"
RDEPENDS:${PN} += "ruby-gem-doorkeeper"

