inherit ruby-gem
GEM_NAME = "stimulus-rails"
SRC_URI[sha256sum] = "19d138829c2d6e6cc22c2c12141d621a8db29400dc93be01dcc9dda2ce227e7c"
RDEPENDS:${PN} += "ruby-gem-railties"

