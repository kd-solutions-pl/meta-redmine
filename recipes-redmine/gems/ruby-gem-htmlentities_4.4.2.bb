inherit ruby-gem
GEM_NAME = "htmlentities"
SRC_URI[sha256sum] = "bbafbdf69f2eca9262be4efef7e43e6a1de54c95eb600f26984f71d2fe96c5c3"
