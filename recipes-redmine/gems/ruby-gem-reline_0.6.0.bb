inherit ruby-gem
GEM_NAME = "reline"
SRC_URI[sha256sum] = "57620375dcbe56ec09bac7192bfb7460c716bbf0054dc94345ecaa5438e539d2"
RDEPENDS:${PN} += "ruby-gem-io-console"

