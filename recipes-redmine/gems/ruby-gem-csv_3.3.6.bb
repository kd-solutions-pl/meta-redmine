inherit ruby-gem
GEM_NAME = "csv"
SRC_URI[sha256sum] = "aba61e7e507a66f03d45cb1f3c4b6359861c3504038b422962875dce099e4456"
