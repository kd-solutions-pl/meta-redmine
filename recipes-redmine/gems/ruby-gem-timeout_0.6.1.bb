inherit ruby-gem
GEM_NAME = "timeout"
SRC_URI[sha256sum] = "78f57368a7e7bbadec56971f78a3f5ecbcfb59b7fcbb0a3ed6ddc08a5094accb"
