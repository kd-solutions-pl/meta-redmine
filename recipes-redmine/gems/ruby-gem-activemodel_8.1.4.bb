inherit ruby-gem
GEM_NAME = "activemodel"
SRC_URI[sha256sum] = "9a0906c127bd118aa5f06157db12b8f750da83dccee72db2f658547a0ae7a0e8"
RDEPENDS:${PN} += "ruby-gem-activesupport"
