inherit ruby-gem
GEM_NAME = "i18n"
SRC_URI[sha256sum] = "00f9eb62412fe593b2a65a97daa75300d37abb8f7202ec748e94b6d46a9dd1b5"
RDEPENDS:${PN} += "ruby-gem-concurrent-ruby"
