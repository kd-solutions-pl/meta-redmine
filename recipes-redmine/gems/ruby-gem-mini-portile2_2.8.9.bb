inherit ruby-gem
GEM_NAME = "mini_portile2"
SRC_URI[sha256sum] = "0cd7c7f824e010c072e33f68bc02d85a00aeb6fce05bb4819c03dfd3c140c289"
