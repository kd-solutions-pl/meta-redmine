inherit ruby-gem
GEM_NAME = "rouge"
SRC_URI[sha256sum] = "20dc56e630fc4903f02c9419af92821a1b9eb8b18bbfdb3af1baea4ebbc79436"

