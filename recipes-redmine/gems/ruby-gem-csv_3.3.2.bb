inherit ruby-gem
GEM_NAME = "csv"
SRC_URI[sha256sum] = "6ff0c135e65e485d1864dde6c1703b60d34cc9e19bed8452834a0b28a519bd4e"

