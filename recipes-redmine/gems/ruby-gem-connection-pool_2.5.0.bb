inherit ruby-gem
GEM_NAME = "connection_pool"
SRC_URI[sha256sum] = "233b92f8d38e038c1349ccea65dd3772727d669d6d2e71f9897c8bf5cd53ebfc"

