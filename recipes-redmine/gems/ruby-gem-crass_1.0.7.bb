inherit ruby-gem
GEM_NAME = "crass"
SRC_URI[sha256sum] = "94868719948664c89ddcaf0a37c65048413dfcb1c869470a5f7a7ceb5390b295"
