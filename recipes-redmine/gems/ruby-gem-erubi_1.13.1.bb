inherit ruby-gem
GEM_NAME = "erubi"
SRC_URI[sha256sum] = "a082103b0885dbc5ecf1172fede897f9ebdb745a4b97a5e8dc63953db1ee4ad9"

