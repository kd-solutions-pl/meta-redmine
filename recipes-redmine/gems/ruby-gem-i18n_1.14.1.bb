inherit ruby-gem
GEM_NAME = "i18n"
SRC_URI[sha256sum] = "9d03698903547c060928e70a9bc8b6b87fda674453cda918fc7ab80235ae4a61"
RDEPENDS:${PN} += "ruby-gem-concurrent-ruby"

