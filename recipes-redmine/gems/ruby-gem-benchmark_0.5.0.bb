inherit ruby-gem
GEM_NAME = "benchmark"
SRC_URI[sha256sum] = "465df122341aedcb81a2a24b4d3bd19b6c67c1530713fd533f3ff034e419236c"
