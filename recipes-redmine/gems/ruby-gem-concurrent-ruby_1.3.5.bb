inherit ruby-gem
GEM_NAME = "concurrent-ruby"
SRC_URI[sha256sum] = "813b3e37aca6df2a21a3b9f1d497f8cbab24a2b94cab325bffe65ee0f6cbebc6"

