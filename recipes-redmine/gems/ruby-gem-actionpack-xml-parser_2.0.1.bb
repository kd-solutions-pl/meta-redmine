inherit ruby-gem
GEM_NAME = "actionpack-xml_parser"
SRC_URI[sha256sum] = "40cb461ee99445314ab580a783fb7413580deb8b28113c9e70ecd7c1b334d5e6"
RDEPENDS:${PN} += "ruby-gem-actionpack ruby-gem-railties"

