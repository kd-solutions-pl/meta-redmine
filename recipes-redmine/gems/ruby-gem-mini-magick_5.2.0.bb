inherit ruby-gem
GEM_NAME = "mini_magick"
SRC_URI[sha256sum] = "2757ffbfdb1d38242d1da9ff1505360ab75d59dc02eb7ab79ff6d5acb1243f4a"
RDEPENDS:${PN} += "imagemagick"

