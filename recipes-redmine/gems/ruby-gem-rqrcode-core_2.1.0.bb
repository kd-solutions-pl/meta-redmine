inherit ruby-gem
GEM_NAME = "rqrcode_core"
SRC_URI[sha256sum] = "f303b85df89c1b8fc5ee8dc19808c9dc4330e6329b660d99d4a8cbb36ca13051"
