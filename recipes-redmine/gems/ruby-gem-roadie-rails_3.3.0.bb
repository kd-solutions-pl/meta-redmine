inherit ruby-gem
GEM_NAME = "roadie-rails"
SRC_URI[sha256sum] = "4080f67a635962fb3df77ed42b2992ff41ee6502b60b5f4609a9fb9eb06c0a5e"
RDEPENDS:${PN} += "ruby-gem-roadie ruby-gem-railties"

