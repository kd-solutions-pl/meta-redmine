inherit ruby-gem
GEM_NAME = "requestjs-rails"
SRC_URI[sha256sum] = "27ea4a92a98d180139dcee50f46d11e2626ce95eb0472d143099b30f9d220321"
RDEPENDS:${PN} += "ruby-gem-rails"

