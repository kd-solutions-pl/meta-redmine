inherit ruby-gem
GEM_NAME = "crass"
SRC_URI[sha256sum] = "dc516022a56e7b3b156099abc81b6d2b08ea1ed12676ac7a5657617f012bd45d"

