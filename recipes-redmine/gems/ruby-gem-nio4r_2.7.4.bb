inherit ruby-gem
GEM_NAME = "nio4r"
SRC_URI[sha256sum] = "d95dee68e0bb251b8ff90ac3423a511e3b784124e5db7ff5f4813a220ae73ca9"

