inherit ruby-gem
GEM_NAME = "globalid"
SRC_URI[sha256sum] = "037f12fbf1d9d7a014d501c2d5c77356fd4ddd96d7a7991d6700bba96706f427"
RDEPENDS:${PN} += "ruby-gem-activesupport"
