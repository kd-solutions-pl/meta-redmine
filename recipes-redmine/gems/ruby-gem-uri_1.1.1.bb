inherit ruby-gem
GEM_NAME = "uri"
SRC_URI[sha256sum] = "379fa58d27ffb1387eaada68c749d1426738bd0f654d812fcc07e7568f5c57c6"
