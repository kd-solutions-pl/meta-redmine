inherit ruby-gem
GEM_NAME = "with_advisory_lock"
SRC_URI[sha256sum] = "bdb1864430853fe9081a7765f2d5b7cc42725c9ccf1901d20e9989828901b94e"
RDEPENDS:${PN} += "ruby-gem-activerecord"

