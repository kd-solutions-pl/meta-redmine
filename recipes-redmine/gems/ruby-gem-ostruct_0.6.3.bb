inherit ruby-gem
GEM_NAME = "ostruct"
SRC_URI[sha256sum] = "95a2ed4a4bd1d190784e666b47b2d3f078e4a9efda2fccf18f84ddc6538ed912"

