inherit ruby-gem
GEM_NAME = "doorkeeper-i18n"
SRC_URI[sha256sum] = "dea73afae44ffbf3bf7f2921b24ca801ee199d931591f15e24cb07af9c45b4a4"
RDEPENDS:${PN} += "ruby-gem-doorkeeper"
