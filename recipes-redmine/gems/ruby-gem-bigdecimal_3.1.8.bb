inherit ruby-gem
GEM_NAME = "bigdecimal"
SRC_URI[sha256sum] = "a89467ed5a44f8ae01824af49cbc575871fa078332e8f77ea425725c1ffe27be"

