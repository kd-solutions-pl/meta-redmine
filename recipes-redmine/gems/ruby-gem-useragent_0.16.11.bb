inherit ruby-gem
GEM_NAME = "useragent"
SRC_URI[sha256sum] = "700e6413ad4bb954bb63547fa098dddf7b0ebe75b40cc6f93b8d54255b173844"

