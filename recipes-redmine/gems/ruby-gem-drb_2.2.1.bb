inherit ruby-gem
GEM_NAME = "drb"
SRC_URI[sha256sum] = "e9d472bf785f558b96b25358bae115646da0dbfd45107ad858b0bc0d935cb340"

