inherit ruby-gem
GEM_NAME = "connection_pool"
SRC_URI[sha256sum] = "33fff5ba71a12d2aa26cb72b1db8bba2a1a01823559fb01d29eb74c286e62e0a"
