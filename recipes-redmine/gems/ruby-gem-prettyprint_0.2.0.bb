inherit ruby-gem
GEM_NAME = "prettyprint"
SRC_URI[sha256sum] = "2bc9e15581a94742064a3cc8b0fb9d45aae3d03a1baa6ef80922627a0766f193"
