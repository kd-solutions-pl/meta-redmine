inherit ruby-gem
GEM_NAME = "importmap-rails"
SRC_URI[sha256sum] = "a9c0543cf1caa5f222c0fef2bfa75c066d21e5c832ac39d31ac309c81f1da675"
RDEPENDS:${PN} += "ruby-gem-actionpack ruby-gem-activesupport ruby-gem-railties"

