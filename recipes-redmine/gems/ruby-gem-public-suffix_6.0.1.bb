inherit ruby-gem
GEM_NAME = "public_suffix"
SRC_URI[sha256sum] = "61d44e1cab5cbbbe5b31068481cf16976dd0dc1b6b07bd95617ef8c5e3e00c6f"

