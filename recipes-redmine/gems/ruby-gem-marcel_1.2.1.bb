inherit ruby-gem
GEM_NAME = "marcel"
SRC_URI[sha256sum] = "1678e9360e32f9eafa917c80029e2f6d10b2715c66a4b87b6d0da9b9cd1f859f"
