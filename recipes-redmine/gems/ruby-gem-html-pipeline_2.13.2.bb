inherit ruby-gem
GEM_NAME = "html-pipeline"
SRC_URI[sha256sum] = "a1de83f7bd2d3464f3a068e391b661983fc6099d194c8d9ceb91ace02dadb803"

