inherit ruby-gem
GEM_NAME = "stimulus-rails"
SRC_URI[sha256sum] = "765676ffa1f33af64ce026d26b48e8ffb2e0b94e0f50e9119e11d6107d67cb06"
RDEPENDS:${PN} += "ruby-gem-railties"
