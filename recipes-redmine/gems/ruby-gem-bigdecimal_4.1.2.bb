inherit ruby-gem
GEM_NAME = "bigdecimal"
SRC_URI[sha256sum] = "53d217666027eab4280346fba98e7d5b66baaae1b9c3c1c0ffe89d48188a3fbd"
