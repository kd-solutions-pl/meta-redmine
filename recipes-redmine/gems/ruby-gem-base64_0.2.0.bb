inherit ruby-gem
GEM_NAME = "base64"
SRC_URI[sha256sum] = "0f25e9b21a02a0cc0cea8ef92b2041035d39350946e8789c562b2d1a3da01507"

