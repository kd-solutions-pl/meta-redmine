inherit ruby-gem
GEM_NAME = "rack"
SRC_URI[sha256sum] = "7e8d424eb8fe7169717ce6720a67cbdcf08e45a9c9ed9f567b622dd238eb5ea3"

