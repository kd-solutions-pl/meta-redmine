inherit ruby-gem
GEM_NAME = "strscan"
SRC_URI[sha256sum] = "aae2db611a225559f21ffbb71765c9a4e60fd262534a9ea84f4f11c7f32f679e"
