inherit ruby-gem
GEM_NAME = "date"
SRC_URI[sha256sum] = "750d06384d7b9c15d562c76291407d89e368dda4d4fff957eb94962d325a0dc0"
