inherit ruby-gem
GEM_NAME = "activejob"
SRC_URI[sha256sum] = "0bc4227ce371b82da119cd27ed91e0deb9b744bbfa266b86e4bd8d1e2a8f6ed8"
RDEPENDS:${PN} += "ruby-gem-activesupport ruby-gem-globalid"

