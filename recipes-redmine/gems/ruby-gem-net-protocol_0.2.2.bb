inherit ruby-gem
GEM_NAME = "net-protocol"
SRC_URI[sha256sum] = "aa73e0cba6a125369de9837b8d8ef82a61849360eba0521900e2c3713aa162a8"
RDEPENDS:${PN} += "ruby-gem-timeout"

