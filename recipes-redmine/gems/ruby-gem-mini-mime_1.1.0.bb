inherit ruby-gem
GEM_NAME = "mini_mime"
SRC_URI[sha256sum] = "30f2cca8a3c62b5c067f73a1834479dbd85d71f1291d65ffac933dc90796674d"

