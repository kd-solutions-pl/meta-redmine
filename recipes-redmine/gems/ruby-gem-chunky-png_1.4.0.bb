inherit ruby-gem
GEM_NAME = "chunky_png"
SRC_URI[sha256sum] = "89d5b31b55c0cf4da3cf89a2b4ebc3178d8abe8cbaf116a1dba95668502fdcfe"

