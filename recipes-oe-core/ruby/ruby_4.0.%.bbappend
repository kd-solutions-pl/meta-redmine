FILESEXTRAPATHS:prepend := "${THISDIR}/ruby:"

PV = "4.0.6"

SRC_URI[sha256sum] = "837d299e8f7ddf2be31a229a7a7e019d354979825117989acb3b32b1a9be262a"
